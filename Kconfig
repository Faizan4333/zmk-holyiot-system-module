## Kconfig
```kconfig
config ZMK_HOLYIOT_SYSTEM
    bool "HolyIoT Custom System Logic"
    default y
    help
      Enable custom HolyIoT battery and LED logic.
```
